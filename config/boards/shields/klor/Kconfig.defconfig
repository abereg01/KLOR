## config/boards/shields/klor_dongle_screen/Kconfig.shield
```kconfig
config SHIELD_KLOR_DONGLE_SCREEN
    def_bool $(shields_list_contains,klor_dongle_screen)
```
